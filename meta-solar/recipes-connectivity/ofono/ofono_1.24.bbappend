FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = "file://0001-Detect-SARA-R4-as-QMI-device.patch"
